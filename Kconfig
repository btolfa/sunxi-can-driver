## Kconfig
```kconfig
config CAN_SUNXI
	tristate "Sun7i, Sun4i CAN bus controller"
	depends on ARCH_SUN4I || ARCH_SUN7I
	default n
	help
	This is the Sun7i, Sun4i Allwinner CAN BUS driver.
```
